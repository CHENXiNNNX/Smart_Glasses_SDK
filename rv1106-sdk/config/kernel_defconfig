## sysdrv/source/kernel/drivers/misc/tg28/Kconfig
```kconfig
config TG28_POWERKEY
    bool "TG28-POWERKey Driver"
    depends on LEDS_WS2812_PWM
    default y
    
```
